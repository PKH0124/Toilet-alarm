# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HT32F52352 Holtek
  pack: Holtek.HT32_DFP.1.0.62
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1FE00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rt-thread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_HT32_DRIVER, RT_USING_LIBC, USE_HT32F52352_SK, USE_HT32F52342_52, USE_MEM_HT32F52352
  c misc: --gnu
  c include: .;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\drivers\include;..\libraries\usbd_library\inc;..\..\..\components\libc\compilers\common\extension;..\..\..\components\finsh;..\..\..\components\drivers\include;..\libraries\HT32_STD_5xxxx_FWLib\library\CMSIS\Include;..\libraries\HT32_STD_5xxxx_FWLib\library\Device\Holtek\HT32F5xxxx\Include;..\..\..\libcpu\arm\common;..\..\..\components\libc\compilers\common\include;..\libraries\ht32_drivers;..\..\..\components\libc\posix\io\epoll;board\inc;applications;..\..\..\libcpu\arm\cortex-m0;..\libraries\HT32_STD_5xxxx_FWLib\library\HT32F5xxxx_Driver\inc;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\phy;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\posix\ipc;sttabs;sttbsp;sttapp;easyflash\inc;easyflash\plugins\types;easyflash\plugins\types\struct2json\inc;easyflash\plugins\types\struct2json\src;easyflash\port;easyflash\src
  asm define: USE_HT32_CHIP=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/src/: board.c ht32_msp.c
    ../libraries/HT32_STD_5xxxx_FWLib/library/Device/Holtek/HT32F5xxxx/Source/ARM/: startup_ht32f5xxxx_01.s
    ../libraries/ht32_drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: msh_parse.c cmd.c msh.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstdio.c kerrno.c rt_vsnprintf_tiny.c kstring.c rt_vsscanf.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/HT32_STD_5xxxx_FWLib/library/HT32F5xxxx_Driver/src/: ht32f5xxxx_pwrcu.c ht32f5xxxx_gpio.c ht32f5xxxx_wdt.c ht32f5xxxx_ckcu.c ht32f5xxxx_ebi.c ht32f5xxxx_bftm.c ht32f5xxxx_i2c.c ht32f5xxxx_mctm.c ht32f5xxxx_rstcu.c ht32f5xxxx_usart.c ht32f5xxxx_rtc.c ht32_cm0plus_misc.c ht32f5xxxx_i2s.c ht32f5xxxx_pdma.c ht32f5xxxx_usbd.c ht32f5xxxx_tm.c ht32f5xxxx_spi.c ht32f5xxxx_sci.c ht32f5xxxx_exti.c ht32f5xxxx_cmp.c ht32f5xxxx_adc.c ht32f5xxxx_crc.c ht32f5xxxx_flash.c
    ../libraries/HT32_STD_5xxxx_FWLib/library/Device/Holtek/HT32F5xxxx/Source/: system_ht32f5xxxx_01.c
  group sttapp
    ./sttapp/: main.c main.h app_data.h app_data.c
  group sttabs
    ./sttabs/: abs_delay.c abs_delay.h abs_ht32led.c abs_ht32led.h abs_lcd.c abs_lcd.h abs_lora.c abs_lora.h readme.md abs_key.c abs_key.h
  group sttbsp
    ./sttbsp/: bsp_debug.c bsp_debug.h bsp_ht32led.c bsp_ht32led.h bsp_lcd.c bsp_lcd.h bsp_lora.c bsp_lora.h readme.md bsp_beep.c bsp_beep.h bsp_led.c bsp_led.h bsp_key.c bsp_key.h bsp_rtc.c bsp_rtc.h
  group easyflash
    ./easyflash/inc/: easyflash.h ef_cfg.h ef_def.h
    ./easyflash/plugins/types/struct2json/inc/: cJSON.h s2j.h s2jdef.h
    ./easyflash/plugins/types/struct2json/src/: cJSON.c s2j.c
    ./easyflash/plugins/types/: ef_types.c ef_types.h
    ./easyflash/port/: ef_port.c
    ./easyflash/src/: easyflash.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
